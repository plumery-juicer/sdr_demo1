options:
  parameters:
    author: RMUC2026-NC
    category: '[RMUC2026-NC]'
    description: Single-device full-duplex self loopback flow graph. TX and RX share one NanoSDR URI and one selected RMUC wave profile. Added SIC alpha/delay estimator based on latest user-provided graph.
    generate_options: qt_gui
    id: RMUC2026_NanoSDR_TRX
    output_language: python
    title: RMUC2026 NanoSDR TRX
  states: {}

blocks:
- name: Time_Sink_Number
  id: variable
  parameters:
    value: '200'
  states: {}
- name: bt
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: info_bw
  id: variable
  parameters:
    value: '540000'
  states: {}
- name: int1_bw
  id: variable
  parameters:
    value: '940000'
  states: {}
- name: int2_bw
  id: variable
  parameters:
    value: '860000'
  states: {}
- name: int3_bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: leak_beta_im
  id: variable
  parameters:
    comment: Info-channel leakage model coefficient imag part.
    value: '0.0'
  states: {}
- name: leak_beta_re
  id: variable
  parameters:
    comment: Info-channel leakage model coefficient real part.
    value: '1'
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '0.005'
  states: {}
- name: record_prefix
  id: variable
  parameters:
    value: '"records/"'
  states: {}
- name: record_samples
  id: variable
  parameters:
    value: int(samp_rate * record_seconds)
  states: {}
- name: record_seconds
  id: variable
  parameters:
    value: '60'
  states: {}
- name: rx_center_freq
  id: variable
  parameters:
    value: '433100000'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: RX gain.
    value: '40'
  states: {}
- name: rx_info_bw
  id: variable
  parameters:
    value: '540000'
  states: {}
- name: rx_info_channel_freq
  id: variable
  parameters:
    comment: Selected information RX channel center.
    value: '433200000'
  states: {}
- name: rx_info_fir_taps
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, rx_info_bw/2, 20000)
  states: {}
- name: rx_int_bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: rx_int_fir_taps
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, rx_int_bw / 2, 20000)
  states: {}
- name: rx_interfere_channel_freq
  id: variable
  parameters:
    comment: Selected interference RX channel center.
    value: '432800000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sdr_uri1
  id: variable
  parameters:
    comment: SDR URI.
    value: '''ip:192.168.2.1'''
  states: {}
- name: sdr_uri2
  id: variable
  parameters:
    comment: SDR URI.
    value: '''ip:192.168.20.1'''
  states: {}
- name: sps
  id: variable
  parameters:
    value: '47'
  states: {}
- name: tx_attenuation1
  id: variable
  parameters:
    comment: TX atten.
    value: '10'
  states: {}
- name: tx_attenuation2
  id: variable
  parameters:
    comment: TX atten.
    value: '60'
  states: {}
- name: tx_center_freq1
  id: variable
  parameters:
    comment: Primary TX center frequency.
    value: '432800000'
  states: {}
- name: tx_center_freq2
  id: variable
  parameters:
    comment: Secondary information TX center frequency.
    value: '433200000'
  states: {}
- name: tx_mod_info_en
  id: variable
  parameters:
    comment: TX modulator gate for information wave.
    value: '0'
  states: {}
- name: tx_mod_int1_en
  id: variable
  parameters:
    comment: TX modulator gate for level-1 interference.
    value: '0'
  states: {}
- name: tx_mod_int2_en
  id: variable
  parameters:
    comment: TX modulator gate for level-2 interference.
    value: '0.0'
  states: {}
- name: tx_mod_int3_en
  id: variable
  parameters:
    comment: TX modulator gate for level-3 interference.
    value: '1'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '170'
    min: '169'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: gui_rx_info_clean_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 8,1,1,1
    name: info spectrum
    type: complex
    ymin: '-120'
  states: {}
- name: gui_rx_info_clean_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 8,0,1,1
    name: info waterfall
    type: complex
  states: {}
- name: gui_rx_info_demod_time_sink
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 3,0,1,1
    label1: Quad demod
    label2: Gaussian match
    name: info baseband
    nconnections: '2'
    size: Time_Sink_Number*sps
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: gui_rx_info_eye_sink
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    gui_hint: 6,0,1,1
    samp_per_symbol: '1'
    size: Time_Sink_Number
    srate: samp_rate/sps
    type: float
    update_time: '0.1'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: gui_rx_info_symbol_time_sink
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 5,0,1,1
    name: Information sync output
    size: Time_Sink_Number
    srate: samp_rate/sps
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: gui_rx_interfere_demod_time_sink
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 3,1,1,1
    label1: Quad demod
    label2: Gaussian match
    name: Int baseband
    nconnections: '2'
    size: Time_Sink_Number*sps
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: gui_rx_interfere_eye_sink
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    gui_hint: 6,1,1,1
    samp_per_symbol: '1'
    size: Time_Sink_Number
    srate: samp_rate/sps
    type: float
    update_time: '0.1'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: gui_rx_interfere_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 9,1,1,1
    name: int spectrum
    type: complex
    ymin: '-120'
  states: {}
- name: gui_rx_interfere_symbol_time_sink
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 5,1,1,1
    name: Interference sync output
    size: Time_Sink_Number
    srate: samp_rate/sps
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: gui_rx_interfere_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 9,0,1,1
    name: int waterfall
    type: complex
  states: {}
- name: gui_rx_power_time_sink
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 10,0,1,1
    name: band power(dBm)
    nconnections: '4'
    size: Time_Sink_Number*sps*100
    srate: samp_rate
    type: float
    ymax: '10'
    ymin: '-80'
  states: {}
- name: gui_rx_raw_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: rx_center_freq
    fftsize: '1024'
    gui_hint: 2,1,1,1
    name: Wideband RX spectrum
    type: complex
    ymin: '-120'
  states: {}
- name: gui_rx_raw_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: rx_center_freq
    fftsize: '1024'
    gui_hint: 2,0,1,1
    name: Wideband RX waterfall
    type: complex
  states: {}
- name: gui_sic_density_number_sink
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    color2: ("blue", "red")
    color3: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 10,1,1,1
    label1: RX RAW
    label2: RX Int
    label3: RX Info
    max: '0'
    min: '-80'
    nconnections: '3'
    type: float
  states: {}
- name: nanosdr_sink
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation1
    bandwidth: samp_rate
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_center_freq1
    samplerate: samp_rate
    type: fc32
    uri: sdr_uri1
  states: {state: disabled}
- name: nanosdr_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation2
    bandwidth: samp_rate
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_center_freq2
    samplerate: samp_rate
    type: fc32
    uri: sdr_uri2
  states: {state: disabled}
- name: nanosdr_source
  id: iio_pluto_source
  parameters:
    bandwidth: bw
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: rx_center_freq
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: sdr_uri1
  states: {}
- name: rx_info_agc
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-5'
    reference: '0.5'
    type: complex
  states: {}
- name: rx_info_bit_slicer
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: rx_info_channel_filter_pre_sic
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rx_info_fir_taps
    type: ccc
  states: {}
- name: rx_info_clean_mag_squared
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: rx_info_clean_power_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: rx_info_clean_power_eps
  id: blocks_add_const_vxx
  parameters:
    const: '1e-12'
    type: float
  states: {}
- name: rx_info_clean_power_iir
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-4'
    type: float
  states: {}
- name: rx_info_demod_rail
  id: analog_rail_ff
  parameters:
    hi: '1.2'
    lo: '-1.2'
  states: {}
- name: rx_info_gaussian_filter
  id: fir_filter_xxx
  parameters:
    comment: Information Gaussian match.
    decim: '1'
    taps: firdes.gaussian(1.0, sps, bt, int(3*sps) + 1)
    type: fff
  states: {}
- name: rx_info_pre_sic_mag_squared
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: rx_info_pre_sic_power_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: rx_info_pre_sic_power_eps
  id: blocks_add_const_vxx
  parameters:
    const: '1e-12'
    type: float
  states: {}
- name: rx_info_pre_sic_power_iir
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-4'
    type: float
  states: {}
- name: rx_info_quad_demod
  id: analog_quadrature_demod_cf
  parameters:
    comment: Info FM discriminator.
    gain: 1/(2*3.141592653589793*((rx_info_bw/2)-(samp_rate/sps))/samp_rate)
  states: {}
- name: rx_info_symbol_sync
  id: digital_symbol_sync_xx
  parameters:
    comment: Info symbol timing.
    damping: '1.0'
    loop_bw: loop_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: rx_interfere_agc
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-5'
    reference: '0.5'
    type: complex
  states: {}
- name: rx_interfere_bit_slicer
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: rx_interfere_channel_filter
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rx_int_fir_taps
    type: ccc
  states: {}
- name: rx_interfere_demod_rail
  id: analog_rail_ff
  parameters:
    hi: '1.2'
    lo: '-1.2'
  states: {}
- name: rx_interfere_freq_shift
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: rx_interfere_gaussian_filter
  id: fir_filter_xxx
  parameters:
    comment: Interference Gaussian match.
    decim: '1'
    taps: firdes.gaussian(1.0, sps, bt, int(3*sps) + 1)
    type: fff
  states: {}
- name: rx_interfere_mag_squared
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: rx_interfere_power_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: rx_interfere_power_eps
  id: blocks_add_const_vxx
  parameters:
    const: '1e-12'
    type: float
  states: {}
- name: rx_interfere_power_iir
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-4'
    type: float
  states: {}
- name: rx_interfere_quad_demod
  id: analog_quadrature_demod_cf
  parameters:
    gain: 1/(2*3.141592653589793*((rx_int_bw/2)-(samp_rate/sps))/samp_rate)
  states: {}
- name: rx_interfere_shift_nco
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: rx_interfere_channel_freq - rx_center_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: rx_interfere_symbol_sync
  id: digital_symbol_sync_xx
  parameters:
    comment: Interference symbol timing.
    damping: '1.0'
    loop_bw: loop_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: rx_power_streams_to_vector
  id: blocks_streams_to_vector
  parameters:
    comment: 'Pack RX power features: raw, interfere, info.'
    num_streams: '3'
    type: float
  states: {}
- name: rx_power_zmq_pub
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:53105
    comment: Publish RX power feature vector.
    timeout: '100'
    type: float
    vlen: '3'
  states: {}
- name: rx_raw_baseband_offset
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: rx_raw_mag_squared
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: rx_raw_power_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: rx_raw_power_eps
  id: blocks_add_const_vxx
  parameters:
    const: '1e-12'
    type: float
  states: {}
- name: rx_raw_power_iir
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-4'
    type: float
  states: {}
- name: rx_raw_power_iir_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-8'
    type: float
  states: {state: disabled}
- name: rx_raw_power_iir_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-8'
    type: float
  states: {state: disabled}
- name: rx_record_rotating_file_sink
  id: epy_block
  parameters:
    _source_code: |
      from block_rotating_file_sink import blk
    comment: 'External block: rotating cfile recorder.'
    dtype: '"complex64"'
    filename_prefix: '"rx_wideband"'
    record_prefix: record_prefix
    sample_rate: samp_rate
    segment_seconds: record_seconds
  states: {}
- name: sic_den_iir_clean
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-6'
    type: float
  states: {}
- name: sic_den_iir_pre
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-6'
    type: float
  states: {}
- name: sic_den_iir_pre_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-6'
    type: float
  states: {}
- name: sic_info_subtract
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: sic_interfere_ref_delay
  id: blocks_delay
  parameters:
    delay: int((len(rx_int_fir_taps) - 1) / 2)
    type: complex
  states: {}
- name: sic_interfere_ref_freq_shift
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: sic_raw_delay
  id: blocks_delay
  parameters:
    delay: int((len(rx_int_fir_taps) - 1) / 2)
    type: complex
  states: {}
- name: sic_raw_freq_shift
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: sic_ref_channel_filter
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rx_info_fir_taps
    type: ccc
  states: {}
- name: sic_ref_leak_gain
  id: blocks_multiply_const_vxx
  parameters:
    const: complex(leak_beta_re, leak_beta_im)
    type: complex
  states: {}
- name: sic_ref_shift_multiply
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: sic_shift_nco
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: rx_info_channel_freq - rx_center_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: tx_file_source_legacy
  id: blocks_file_source
  parameters:
    comment: Red Interf One
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: tx_file_throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: tx_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: tx_center_freq1
    fftsize: '1024'
    gui_hint: 0,1,1,1
    name: TX spectrum
    type: complex
    ymin: '-120'
  states: {state: disabled}
- name: tx_freq_sink_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: tx_center_freq2
    fftsize: '1024'
    gui_hint: 1,1,1,1
    name: TX spectrum
    type: complex
    ymin: '-120'
  states: {state: disabled}
- name: tx_mod_info
  id: digital_gfsk_mod
  parameters:
    bt: bt
    comment: Fixed information-wave GFSK modulator.
    samples_per_symbol: sps
    sensitivity: 2*3.141592653589793*((info_bw/2)-(samp_rate/sps))/samp_rate
  states: {state: disabled}
- name: tx_mod_info_0
  id: digital_gfsk_mod
  parameters:
    bt: bt
    comment: Fixed information-wave GFSK modulator.
    samples_per_symbol: sps
    sensitivity: 2*3.141592653589793*((info_bw/2)-(samp_rate/sps))/samp_rate
  states: {state: disabled}
- name: tx_mod_info_0_0
  id: digital_gfsk_mod
  parameters:
    bt: bt
    comment: Fixed information-wave GFSK modulator.
    samples_per_symbol: sps
    sensitivity: 2*3.141592653589793*((info_bw/2)-(samp_rate/sps))/samp_rate
  states: {state: disabled}
- name: tx_mod_info_gate
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_mod_info_en
    type: complex
  states: {state: disabled}
- name: tx_mod_int1
  id: digital_gfsk_mod
  parameters:
    bt: bt
    comment: Fixed level-1 interference GFSK modulator.
    samples_per_symbol: sps
    sensitivity: 2*3.141592653589793*((int1_bw/2)-(samp_rate/sps))/samp_rate
  states: {state: disabled}
- name: tx_mod_int1_gate
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_mod_int1_en
    type: complex
  states: {state: disabled}
- name: tx_mod_int2
  id: digital_gfsk_mod
  parameters:
    bt: bt
    comment: Fixed level-2 interference GFSK modulator.
    samples_per_symbol: sps
    sensitivity: 2*3.141592653589793*((int2_bw/2)-(samp_rate/sps))/samp_rate
  states: {state: disabled}
- name: tx_mod_int2_gate
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_mod_int2_en
    type: complex
  states: {state: disabled}
- name: tx_mod_int3
  id: digital_gfsk_mod
  parameters:
    bt: bt
    comment: Fixed level-3 interference GFSK modulator.
    samples_per_symbol: sps
    sensitivity: 2*3.141592653589793*((int3_bw/2)-(samp_rate/sps))/samp_rate
  states: {state: disabled}
- name: tx_mod_int3_gate
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_mod_int3_en
    type: complex
  states: {state: disabled}
- name: tx_modulated_wave_add
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {state: disabled}
- name: tx_waterfall_sink
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: tx_center_freq1
    fftsize: '1024'
    gui_hint: 0,0,1,1
    name: TX waterfall
    type: complex
  states: {state: disabled}
- name: tx_waterfall_sink_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: tx_center_freq2
    fftsize: '1024'
    gui_hint: 1,0,1,1
    name: TX waterfall
    type: complex
  states: {state: disabled}
- name: tx_zmq_info_file_source
  id: blocks_file_source
  parameters:
    comment: Red Interf One
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: tx_zmq_interfere_file_source
  id: blocks_file_source
  parameters:
    comment: Red Interf One
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: tx_zmq_padding_file_source
  id: blocks_file_source
  parameters:
    comment: Red Interf One
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: tx_zmq_stream_add
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: xmlrpc_server
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '53106'
  states: {}
- name: zmq_bits_in
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:53101
    timeout: '100'
    type: byte
  states: {state: disabled}
- name: zmq_bits_in_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:53102
    timeout: '100'
    type: byte
  states: {state: disabled}
- name: zmq_info_bits_out
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:53103
    timeout: '100'
    type: byte
  states: {}
- name: zmq_interfere_bits_out
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:53104
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_random_source_x_0, '0', tx_mod_info, '0']
- [analog_random_source_x_0, '0', tx_mod_int1, '0']
- [analog_random_source_x_0, '0', tx_mod_int2, '0']
- [analog_random_source_x_0, '0', tx_mod_int3, '0']
- [analog_random_source_x_0_0, '0', tx_mod_info_0_0, '0']
- [blocks_sub_xx_0, '0', rx_interfere_symbol_sync, '0']
- [blocks_sub_xx_0_0, '0', rx_info_symbol_sync, '0']
- [nanosdr_source, '0', rx_raw_baseband_offset, '0']
- [nanosdr_source, '0', rx_record_rotating_file_sink, '0']
- [rx_info_agc, '0', rx_info_quad_demod, '0']
- [rx_info_bit_slicer, '0', zmq_info_bits_out, '0']
- [rx_info_channel_filter_pre_sic, '0', rx_info_pre_sic_mag_squared, '0']
- [rx_info_channel_filter_pre_sic, '0', sic_info_subtract, '0']
- [rx_info_clean_mag_squared, '0', rx_info_clean_power_iir, '0']
- [rx_info_clean_power_db, '0', gui_rx_power_time_sink, '3']
- [rx_info_clean_power_db, '0', sic_den_iir_clean, '0']
- [rx_info_clean_power_eps, '0', rx_info_clean_power_db, '0']
- [rx_info_clean_power_iir, '0', rx_info_clean_power_eps, '0']
- [rx_info_demod_rail, '0', gui_rx_info_demod_time_sink, '0']
- [rx_info_demod_rail, '0', rx_info_gaussian_filter, '0']
- [rx_info_gaussian_filter, '0', blocks_sub_xx_0_0, '0']
- [rx_info_gaussian_filter, '0', gui_rx_info_demod_time_sink, '1']
- [rx_info_gaussian_filter, '0', rx_info_symbol_sync, '0']
- [rx_info_gaussian_filter, '0', rx_raw_power_iir_0_0, '0']
- [rx_info_pre_sic_mag_squared, '0', rx_info_pre_sic_power_iir, '0']
- [rx_info_pre_sic_power_db, '0', gui_rx_power_time_sink, '2']
- [rx_info_pre_sic_power_eps, '0', rx_info_pre_sic_power_db, '0']
- [rx_info_pre_sic_power_iir, '0', rx_info_pre_sic_power_eps, '0']
- [rx_info_quad_demod, '0', rx_info_demod_rail, '0']
- [rx_info_symbol_sync, '0', gui_rx_info_eye_sink, '0']
- [rx_info_symbol_sync, '0', gui_rx_info_symbol_time_sink, '0']
- [rx_info_symbol_sync, '0', rx_info_bit_slicer, '0']
- [rx_interfere_agc, '0', rx_interfere_quad_demod, '0']
- [rx_interfere_bit_slicer, '0', zmq_interfere_bits_out, '0']
- [rx_interfere_channel_filter, '0', gui_rx_interfere_freq_sink, '0']
- [rx_interfere_channel_filter, '0', gui_rx_interfere_waterfall, '0']
- [rx_interfere_channel_filter, '0', rx_interfere_agc, '0']
- [rx_interfere_channel_filter, '0', rx_interfere_mag_squared, '0']
- [rx_interfere_channel_filter, '0', sic_ref_shift_multiply, '0']
- [rx_interfere_demod_rail, '0', gui_rx_interfere_demod_time_sink, '0']
- [rx_interfere_demod_rail, '0', rx_interfere_gaussian_filter, '0']
- [rx_interfere_freq_shift, '0', rx_interfere_channel_filter, '0']
- [rx_interfere_gaussian_filter, '0', blocks_sub_xx_0, '0']
- [rx_interfere_gaussian_filter, '0', gui_rx_interfere_demod_time_sink, '1']
- [rx_interfere_gaussian_filter, '0', rx_interfere_symbol_sync, '0']
- [rx_interfere_gaussian_filter, '0', rx_raw_power_iir_0, '0']
- [rx_interfere_mag_squared, '0', rx_interfere_power_iir, '0']
- [rx_interfere_power_db, '0', gui_rx_power_time_sink, '1']
- [rx_interfere_power_db, '0', sic_den_iir_pre, '0']
- [rx_interfere_power_eps, '0', rx_interfere_power_db, '0']
- [rx_interfere_power_iir, '0', rx_interfere_power_eps, '0']
- [rx_interfere_quad_demod, '0', rx_interfere_demod_rail, '0']
- [rx_interfere_shift_nco, '0', rx_interfere_freq_shift, '1']
- [rx_interfere_shift_nco, '0', sic_interfere_ref_delay, '0']
- [rx_interfere_symbol_sync, '0', gui_rx_interfere_eye_sink, '0']
- [rx_interfere_symbol_sync, '0', gui_rx_interfere_symbol_time_sink, '0']
- [rx_interfere_symbol_sync, '0', rx_interfere_bit_slicer, '0']
- [rx_power_streams_to_vector, '0', rx_power_zmq_pub, '0']
- [rx_raw_baseband_offset, '0', gui_rx_raw_freq_sink, '0']
- [rx_raw_baseband_offset, '0', gui_rx_raw_waterfall, '0']
- [rx_raw_baseband_offset, '0', rx_interfere_freq_shift, '0']
- [rx_raw_baseband_offset, '0', sic_raw_delay, '0']
- [rx_raw_mag_squared, '0', rx_raw_power_iir, '0']
- [rx_raw_power_db, '0', gui_rx_power_time_sink, '0']
- [rx_raw_power_db, '0', sic_den_iir_pre_0, '0']
- [rx_raw_power_eps, '0', rx_raw_power_db, '0']
- [rx_raw_power_iir, '0', rx_raw_power_eps, '0']
- [rx_raw_power_iir_0, '0', blocks_sub_xx_0, '1']
- [rx_raw_power_iir_0_0, '0', blocks_sub_xx_0_0, '1']
- [sic_den_iir_clean, '0', gui_sic_density_number_sink, '2']
- [sic_den_iir_clean, '0', rx_power_streams_to_vector, '2']
- [sic_den_iir_pre, '0', gui_sic_density_number_sink, '1']
- [sic_den_iir_pre, '0', rx_power_streams_to_vector, '1']
- [sic_den_iir_pre_0, '0', gui_sic_density_number_sink, '0']
- [sic_den_iir_pre_0, '0', rx_power_streams_to_vector, '0']
- [sic_info_subtract, '0', gui_rx_info_clean_freq_sink, '0']
- [sic_info_subtract, '0', gui_rx_info_clean_waterfall, '0']
- [sic_info_subtract, '0', rx_info_agc, '0']
- [sic_info_subtract, '0', rx_info_clean_mag_squared, '0']
- [sic_interfere_ref_delay, '0', sic_ref_shift_multiply, '1']
- [sic_interfere_ref_freq_shift, '0', sic_ref_channel_filter, '0']
- [sic_raw_delay, '0', sic_raw_freq_shift, '0']
- [sic_raw_freq_shift, '0', rx_info_channel_filter_pre_sic, '0']
- [sic_ref_channel_filter, '0', sic_ref_leak_gain, '0']
- [sic_ref_leak_gain, '0', sic_info_subtract, '1']
- [sic_ref_shift_multiply, '0', sic_interfere_ref_freq_shift, '0']
- [sic_shift_nco, '0', sic_interfere_ref_freq_shift, '1']
- [sic_shift_nco, '0', sic_raw_freq_shift, '1']
- [tx_file_source_legacy, '0', nanosdr_sink, '0']
- [tx_file_source_legacy, '0', tx_freq_sink, '0']
- [tx_file_source_legacy, '0', tx_waterfall_sink, '0']
- [tx_file_throttle, '0', rx_raw_baseband_offset, '0']
- [tx_mod_info, '0', tx_mod_info_gate, '0']
- [tx_mod_info_0, '0', nanosdr_sink_0, '0']
- [tx_mod_info_0, '0', tx_freq_sink_0, '0']
- [tx_mod_info_0, '0', tx_waterfall_sink_0, '0']
- [tx_mod_info_0_0, '0', rx_raw_baseband_offset, '0']
- [tx_mod_info_0_0, '0', rx_record_rotating_file_sink, '0']
- [tx_mod_info_gate, '0', tx_modulated_wave_add, '0']
- [tx_mod_int1, '0', tx_mod_int1_gate, '0']
- [tx_mod_int1_gate, '0', tx_modulated_wave_add, '1']
- [tx_mod_int2, '0', tx_mod_int2_gate, '0']
- [tx_mod_int2_gate, '0', tx_modulated_wave_add, '2']
- [tx_mod_int3, '0', tx_mod_int3_gate, '0']
- [tx_mod_int3_gate, '0', tx_modulated_wave_add, '3']
- [tx_modulated_wave_add, '0', nanosdr_sink, '0']
- [tx_modulated_wave_add, '0', tx_freq_sink, '0']
- [tx_modulated_wave_add, '0', tx_waterfall_sink, '0']
- [tx_zmq_info_file_source, '0', tx_file_throttle, '0']
- [tx_zmq_interfere_file_source, '0', tx_file_throttle, '0']
- [tx_zmq_interfere_file_source, '0', tx_zmq_stream_add, '0']
- [tx_zmq_padding_file_source, '0', tx_file_throttle, '0']
- [tx_zmq_padding_file_source, '0', tx_zmq_stream_add, '1']
- [tx_zmq_stream_add, '0', tx_file_throttle, '0']
- [zmq_bits_in, '0', tx_mod_info, '0']
- [zmq_bits_in, '0', tx_mod_int1, '0']
- [zmq_bits_in, '0', tx_mod_int2, '0']
- [zmq_bits_in, '0', tx_mod_int3, '0']
- [zmq_bits_in_0, '0', tx_mod_info_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
